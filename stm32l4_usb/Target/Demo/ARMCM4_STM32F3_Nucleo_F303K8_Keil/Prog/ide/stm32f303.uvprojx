# Keil uVision project stm32f303.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: demoprog_stm32f303
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32f303.srec ..\bin\demoprog_stm32f303.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303x8
  c misc: --diag_suppress=111
  c include: ..\..\Prog;..\lib;..\lib\CMSIS\Device\ST\STM32F3xx\Include;..\lib\CMSIS\Include;..\lib\STM32F3xx_HAL_Driver\Inc;..\lib\STM32F3xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  scatter file: ..\stm32f303.sct
  group Lib
    ../lib/CMSIS/Device/ST/STM32F3xx/Include/: stm32f3xx.h stm32f303x8.h system_stm32f3xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h tz_context.h
    ../lib/STM32F3xx_HAL_Driver/Inc/: stm32f3xx_hal.h stm32f3xx_hal_can.h stm32f3xx_hal_cortex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_exti.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.h
    ../lib/STM32F3xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_can.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
    ../lib/: stm32f3xx_hal_conf.h system_stm32f3xx.c
  group App
    ../: boot.c boot.h header.h led.c led.h main.c timer.c timer.h startup_stm32f303x8.s
software components: CMSIS:CORE 4.3.0
