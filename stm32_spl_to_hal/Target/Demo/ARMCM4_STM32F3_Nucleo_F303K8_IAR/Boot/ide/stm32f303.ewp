# IAR project stm32f303.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303K8 ST STM32F303K8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303K8; STM32F334x8; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\cmsis; ..\lib\SPL\inc; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM4_STM32F3; ..\..\..\..\Source\ARMCM4_STM32F3\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32f303.srec
  ILINK.IlinkOutputFile: openblt_stm32f303.out
  ILINK.IlinkIcfFile: ..\stm32f303k8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32f303.s
  group Boot/lib
    ../lib/: stm32f30x.h stm32f30x_conf.h system_stm32f30x.c system_stm32f30x.h
  group Boot/lib/cmsis
    ../lib/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Boot/lib/SPL
    ../lib/SPL/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
    ../lib/SPL/inc/: stm32f30x_adc.h stm32f30x_can.h stm32f30x_comp.h stm32f30x_crc.h stm32f30x_dac.h stm32f30x_dbgmcu.h stm32f30x_dma.h stm32f30x_exti.h stm32f30x_flash.h stm32f30x_fmc.h stm32f30x_gpio.h stm32f30x_hrtim.h stm32f30x_i2c.h stm32f30x_iwdg.h stm32f30x_misc.h stm32f30x_opamp.h stm32f30x_pwr.h stm32f30x_rcc.h stm32f30x_rtc.h stm32f30x_spi.h stm32f30x_syscfg.h stm32f30x_tim.h stm32f30x_usart.h stm32f30x_wwdg.h
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h timer.h uart.h usb.h xcp.c xcp.h
  group Source/ARMCM4_STM32F3
    ../../../../Source/ARMCM4_STM32F3/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h uart.c
  group Source/ARMCM4_STM32F3/IAR
    ../../../../Source/ARMCM4_STM32F3/IAR/: cpu_comp.c
