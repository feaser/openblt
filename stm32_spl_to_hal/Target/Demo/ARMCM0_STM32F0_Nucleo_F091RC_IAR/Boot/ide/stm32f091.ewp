# IAR project stm32f091.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F091; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\lib; ..\lib\cmsis; ..\lib\SPL\inc; ..\; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM0_STM32F0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32f091.srec
  ILINK.IlinkOutputFile: openblt_stm32f091.out
  ILINK.IlinkIcfFile: ..\stm32f091_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32f091.s
  group Boot/lib
    ../lib/: stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
  group Boot/lib/cmsis
    ../lib/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cmFunc.h core_cmInstr.h
  group Boot/lib/SPL/inc
    ../lib/SPL/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group Boot/lib/SPL/src
    ../lib/SPL/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h timer.h uart.h usb.h xcp.c xcp.h
  group Source/ARMCM0_STM32F0
    ../../../../Source/ARMCM0_STM32F0/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h uart.c
  group Source/ARMCM0_STM32F0/IAR
    ../../../../Source/ARMCM0_STM32F0/IAR/: cpu_comp.c
