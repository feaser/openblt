# IAR project stm32f405.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; __FPU_USED; STM32F405RG; STM32F4XX; USE_STDPERIPH_DRIVER; HSE_VALUE=8000000; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\cmsis; ..\lib\fatfs; ..\lib\SPL\inc; ..\lib\usbdevicelib\Core\inc; ..\lib\usbotgdriver\inc; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM4_STM32F4; ..\..\..\..\Source\third_party\fatfs\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_olimex_stm32p405.srec
  ILINK.IlinkOutputFile: openblt_olimex_stm32p405.out
  ILINK.IlinkIcfFile: ..\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Boot
    ../: blt_conf.h flash_layout.c hooks.c led.c led.h main.c startup_stm32f40xx.s usb_bsp.c usb_conf.h usbd_bulk.c usbd_bulk.h usbd_conf.h usbd_desc.c usbd_desc.h usbd_usr.c
  group Boot/lib
    ../lib/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group Boot/lib/cmsis
    ../lib/cmsis/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/SPL/inc
    ../lib/SPL/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Boot/lib/SPL/src
    ../lib/SPL/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Boot/lib/usbdevicelib/inc
    ../lib/usbdevicelib/Core/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group Boot/lib/usbdevicelib/src
    ../lib/usbdevicelib/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group Boot/lib/usbotgdriver/inc
    ../lib/usbotgdriver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
  group Boot/lib/usbotgdriver/src
    ../lib/usbotgdriver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h timer.h uart.h usb.h xcp.c xcp.h
  group Source/ARMCM4_STM32F4
    ../../../../Source/ARMCM4_STM32F4/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h uart.c usb.c
  group Source/ARMCM4_STM32F4/IAR
    ../../../../Source/ARMCM4_STM32F4/IAR/: cpu_comp.c
  group Source/thrid_party/fatfs
    ../../../../Source/third_party/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/third_party/fatfs/src/option/: unicode.c
