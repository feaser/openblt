# IAR project stm32f303.ewp, settings and files
configuration Prog (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RC ST STM32F303RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Device\ST\STM32F3xx\Include; ..\lib\CMSIS\Include; ..\lib\STM32F3xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_olimexino_stm32f3.srec
  ILINK.IlinkOutputFile: demoprog_olimexino_stm32f3.out
  ILINK.IlinkIcfFile: ..\stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Prog
    ../: boot.c boot.h header.h led.c led.h main.c startup_stm32f303xc.s timer.c timer.h
  group Prog/lib
    ../lib/: stm32f3xx_hal_conf.h system_stm32f3xx.c
  group Prog/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32F3xx/Include/: stm32f303xc.h stm32f3xx.h system_stm32f3xx.h
  group Prog/lib/HAL_Driver
    ../lib/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_can.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
    ../lib/STM32F3xx_HAL_Driver/Inc/: stm32f3xx_hal.h stm32f3xx_hal_can.h stm32f3xx_hal_cortex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_exti.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.h stm32f3xx_ll_bus.h stm32f3xx_ll_cortex.h stm32f3xx_ll_dma.h stm32f3xx_ll_exti.h stm32f3xx_ll_gpio.h stm32f3xx_ll_pwr.h stm32f3xx_ll_rcc.h stm32f3xx_ll_system.h stm32f3xx_ll_usart.h stm32f3xx_ll_utils.h
