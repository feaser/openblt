# IAR project stm32l073.ewp, settings and files
configuration stm32l073 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32L073xx
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32L0xx\Include; ..\lib\STM32L0xx_HAL_Driver\Inc; ..\lib\STM32L0xx_HAL_Driver\Inc\Legacy; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM0_STM32L0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32l073.srec
  ILINK.IlinkOutputFile: openblt_stm32l073.out
  ILINK.IlinkIcfFile: ..\stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32l073xx.s
  group Boot/lib
    ../lib/: stm32l0xx_hal_conf.h system_stm32l0xx.c
  group Boot/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32L0xx/Include/: stm32l073xx.h stm32l0xx.h system_stm32l0xx.h
  group Boot/lib/HAL_Driver
    ../lib/STM32L0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_rcc.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
    ../lib/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal.h stm32l0xx_hal_cortex.h stm32l0xx_hal_def.h stm32l0xx_hal_dma.h stm32l0xx_hal_exti.h stm32l0xx_hal_flash.h stm32l0xx_hal_flash_ex.h stm32l0xx_hal_flash_ramfunc.h stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c.h stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rcc.h stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_tim.h stm32l0xx_hal_tim_ex.h stm32l0xx_ll_bus.h stm32l0xx_ll_cortex.h stm32l0xx_ll_crs.h stm32l0xx_ll_dma.h stm32l0xx_ll_exti.h stm32l0xx_ll_gpio.h stm32l0xx_ll_pwr.h stm32l0xx_ll_rcc.h stm32l0xx_ll_system.h stm32l0xx_ll_usart.h stm32l0xx_ll_utils.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM0_STM32L0
    ../../../../Source/ARMCM0_STM32L0/: cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h
  group Source/ARMCM0_STM32L0/IAR
    ../../../../Source/ARMCM0_STM32L0/IAR/: cpu_comp.c
