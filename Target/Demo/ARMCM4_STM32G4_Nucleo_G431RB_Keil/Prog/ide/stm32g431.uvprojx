# Keil uVision project stm32g431.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: demoprog_stm32g431
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32g431.srec ..\bin\demoprog_stm32g431.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c misc: --diag_suppress=111
  c include: ..\..\Prog;..\lib;..\lib\CMSIS\Device\ST\STM32G4xx\Include;..\lib\CMSIS\Include;..\lib\STM32G4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\stm32g431.sct
  group App
    ../: boot.c boot.h header.h led.c led.h main.c timer.c timer.h startup_stm32g431xx.s
  group Lib
    ../lib/: stm32g4xx_hal_conf.h system_stm32g4xx.c
    ../lib/CMSIS/Device/ST/STM32G4xx/Include/: stm32g4xx.h stm32g431xx.h system_stm32g4xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h tz_context.h
    ../lib/STM32G4xx_HAL_Driver/Inc/: stm32g4xx_hal.h stm32g4xx_hal_cortex.h stm32g4xx_hal_def.h stm32g4xx_hal_dma.h stm32g4xx_hal_dma_ex.h stm32g4xx_hal_exti.h stm32g4xx_hal_fdcan.h stm32g4xx_hal_flash.h stm32g4xx_hal_flash_ex.h stm32g4xx_hal_flash_ramfunc.h stm32g4xx_hal_gpio.h stm32g4xx_hal_gpio_ex.h stm32g4xx_hal_pwr.h stm32g4xx_hal_pwr_ex.h stm32g4xx_hal_rcc.h stm32g4xx_hal_rcc_ex.h stm32g4xx_hal_tim.h stm32g4xx_hal_tim_ex.h stm32g4xx_hal_uart.h stm32g4xx_hal_uart_ex.h stm32g4xx_ll_bus.h stm32g4xx_ll_cortex.h stm32g4xx_ll_crs.h stm32g4xx_ll_dma.h stm32g4xx_ll_dmamux.h stm32g4xx_ll_exti.h stm32g4xx_ll_gpio.h stm32g4xx_ll_lpuart.h stm32g4xx_ll_pwr.h stm32g4xx_ll_rcc.h stm32g4xx_ll_system.h stm32g4xx_ll_usart.h stm32g4xx_ll_utils.h
    ../lib/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
