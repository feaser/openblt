# IAR project stm32f103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\ARMCM3_STM32; ..\..\..\..\Source\ARMCM3_STM32\IAR; ..; ..\lib\CMSIS\CM3\CoreSupport; ..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\lib\USB_FS_DEVICE\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openbtl_olimex_stm32h103.srec
  ILINK.IlinkOutputFile: openbtl_olimex_stm32h103.out
  ILINK.IlinkIcfFile: ..\..\..\..\Source\ARMCM3_STM32\IAR\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Boot
    ../: blt_conf.h hooks.c main.c usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
  group Boot/lib
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Boot/lib/usb
    ../lib/USB_FS_DEVICE/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../lib/USB_FS_DEVICE/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h nvm.h plausibility.h timer.h uart.h usb.h xcp.c xcp.h
  group Source/ARMCM3_STM32
    ../../../../Source/ARMCM3_STM32/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h uart.c usb.c
  group Source/ARMCM3_STM32/IAR
    ../../../../Source/ARMCM3_STM32/IAR/: cstart.s vectors.c
