<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32c092.ewp</path>
  </project>
  <batchBuild />
</workspace>
