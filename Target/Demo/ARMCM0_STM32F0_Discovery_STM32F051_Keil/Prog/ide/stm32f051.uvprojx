# Keil uVision project stm32f051.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: demoprog_stm32f051
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32f051.srec ..\bin\demoprog_stm32f051.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F051x8,USE_HAL_DRIVER
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32F0xx\Include;..\lib\CMSIS\Include;..\lib\STM32F0xx_HAL_Driver\Inc;..\lib\STM32F0xx_HAL_Driver\Inc\Legacy;..\..\Prog
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\stm32f051.sct
  group Lib
    ../lib/: stm32f0xx_hal_conf.h system_stm32f0xx.c
    ../lib/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h stm32f051x8.h system_stm32f0xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    ../lib/STM32F0xx_HAL_Driver/Inc/: stm32f0xx_hal.h stm32f0xx_hal_cortex.h stm32f0xx_hal_def.h stm32f0xx_hal_dma.h stm32f0xx_hal_dma_ex.h stm32f0xx_hal_exti.h stm32f0xx_hal_flash.h stm32f0xx_hal_flash_ex.h stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc_ex.h stm32f0xx_hal_uart.h stm32f0xx_hal_uart_ex.h stm32f0xx_ll_bus.h stm32f0xx_ll_cortex.h stm32f0xx_ll_crs.h stm32f0xx_ll_dma.h stm32f0xx_ll_exti.h stm32f0xx_ll_gpio.h stm32f0xx_ll_pwr.h stm32f0xx_ll_rcc.h stm32f0xx_ll_system.h stm32f0xx_ll_usart.h stm32f0xx_ll_utils.h
    ../lib/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group App
    ../: boot.c boot.h header.h led.c led.h main.c timer.c timer.h startup_stm32f051.s
