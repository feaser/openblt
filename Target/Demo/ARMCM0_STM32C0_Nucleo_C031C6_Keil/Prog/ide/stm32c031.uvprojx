# Keil uVision project stm32c031.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: demoprog_stm32c031
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32c031.srec ..\bin\demoprog_stm32c031.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32C031xx
  c misc: --diag_suppress=111
  c include: ..\lib;..\lib\CMSIS\Device\ST\STM32C0xx\Include;..\lib\CMSIS\Include;..\lib\STM32C0xx_HAL_Driver\Inc;..\..\Prog
  memory RVCT4: ROM 0x8002000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: ..\stm32c031.sct
  group Lib
    ../lib/: stm32c0xx_hal_conf.h system_stm32c0xx.c
    ../lib/CMSIS/Device/ST/STM32C0xx/Include/: stm32c0xx.h stm32c031xx.h system_stm32c0xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_version.h core_cm0plus.h
    ../lib/STM32C0xx_HAL_Driver/Inc/: stm32c0xx_hal.h stm32c0xx_hal_cortex.h stm32c0xx_hal_def.h stm32c0xx_hal_dma.h stm32c0xx_hal_dma_ex.h stm32c0xx_hal_exti.h stm32c0xx_hal_flash.h stm32c0xx_hal_flash_ex.h stm32c0xx_hal_gpio.h stm32c0xx_hal_gpio_ex.h stm32c0xx_hal_pwr.h stm32c0xx_hal_pwr_ex.h stm32c0xx_hal_rcc.h stm32c0xx_hal_rcc_ex.h stm32c0xx_hal_uart.h stm32c0xx_hal_uart_ex.h stm32c0xx_ll_bus.h stm32c0xx_ll_cortex.h stm32c0xx_ll_dma.h stm32c0xx_ll_dmamux.h stm32c0xx_ll_exti.h stm32c0xx_ll_gpio.h stm32c0xx_ll_pwr.h stm32c0xx_ll_rcc.h stm32c0xx_ll_system.h stm32c0xx_ll_usart.h stm32c0xx_ll_utils.h
    ../lib/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c
  group App
    ../: boot.c boot.h header.h led.c led.h main.c timer.c timer.h startup_stm32c031xx.s
