# IAR project stm32f103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\fatfs; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32F1xx\Include; ..\lib\STM32F1xx_HAL_Driver\Inc; ..\lib\STM32F1xx_HAL_Driver\Inc\Legacy; ..\lib\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM3_STM32F1; ..\..\..\..\Source\third_party\fatfs\src
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_olimexino_stm32.srec
  ILINK.IlinkOutputFile: openblt_olimexino_stm32.out
  ILINK.IlinkIcfFile: ..\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Boot
    ../: blt_conf.h flash_layout.c hooks.c led.c led.h main.c startup_stm32f103xb.s usbd_bulk.c usbd_bulk.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h
  group Boot/lib
    ../lib/: stm32f1xx_hal_conf.h system_stm32f1xx.c
  group Boot/lib/cmsis
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../lib/CMSIS/Device/ST/STM32F1xx/Include/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/hal
    ../lib/STM32F1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_rcc.c stm32f1xx_ll_spi.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
    ../lib/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cortex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_dma.h stm32f1xx_ll_exti.h stm32f1xx_ll_gpio.h stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.h stm32f1xx_ll_spi.h stm32f1xx_ll_system.h stm32f1xx_ll_usart.h stm32f1xx_ll_usb.h stm32f1xx_ll_utils.h
  group Boot/lib/usb
    ../lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../lib/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h timer.h uart.h usb.h xcp.c xcp.h
  group Source/ARMCM3_STM32F1
    ../../../../Source/ARMCM3_STM32F1/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h uart.c usb.c
  group Source/ARMCM3_STM32F1/IAR
    ../../../../Source/ARMCM3_STM32F1/IAR/: cpu_comp.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/third_party/fatfs/src/option/: unicode.c
