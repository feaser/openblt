# Keil uVision project stm32h563.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: demoprog_stm32h563
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32h563.srec ..\bin\demoprog_stm32h563.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ..\..\Prog;..\lib;..\lib\CMSIS\Device\ST\STM32H5xx\Include;..\lib\CMSIS\Include;..\lib\STM32H5xx_HAL_Driver\Inc;..\lib\STM32H5xx_HAL_Driver\Inc\Legacy;..\lib\uip;..\..\..\..\Source\third_party\uip\uip;..\..\..\..\Source\third_party\uip\apps\dhcpc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  scatter file: ..\stm32h563.sct
  group Lib
    ../lib/CMSIS/Device/ST/STM32H5xx/Include/: stm32h5xx.h stm32h563xx.h system_stm32h5xx.h
    ../lib/CMSIS/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_armv81mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_cm35p.h core_cm55.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h mpu_armv7.h mpu_armv8.h pac_armv81.h pmu_armv8.h tz_context.h
    ../lib/STM32H5xx_HAL_Driver/Inc/: stm32h5xx_hal.h stm32h5xx_hal_cortex.h stm32h5xx_hal_def.h stm32h5xx_hal_dma.h stm32h5xx_hal_dma_ex.h stm32h5xx_hal_eth.h stm32h5xx_hal_eth_ex.h stm32h5xx_hal_exti.h stm32h5xx_hal_fdcan.h stm32h5xx_hal_flash.h stm32h5xx_hal_flash_ex.h stm32h5xx_hal_gpio.h stm32h5xx_hal_gpio_ex.h stm32h5xx_hal_icache.h stm32h5xx_hal_pwr.h stm32h5xx_hal_pwr_ex.h stm32h5xx_hal_rcc.h stm32h5xx_hal_rcc_ex.h stm32h5xx_hal_tim.h stm32h5xx_hal_tim_ex.h stm32h5xx_hal_uart.h stm32h5xx_hal_uart_ex.h stm32h5xx_ll_bus.h stm32h5xx_ll_cortex.h stm32h5xx_ll_crs.h stm32h5xx_ll_dma.h stm32h5xx_ll_exti.h stm32h5xx_ll_gpio.h stm32h5xx_ll_icache.h stm32h5xx_ll_lpuart.h stm32h5xx_ll_pwr.h stm32h5xx_ll_rcc.h stm32h5xx_ll_system.h stm32h5xx_ll_usart.h stm32h5xx_ll_utils.h
    ../lib/STM32H5xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_eth.c stm32h5xx_hal_eth_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
    ../lib/uip/: clock-arch.c clock-arch.h lan8742.c lan8742.h netdev.c netdev.h uip-conf.h
    ../lib/: stm32h5xx_hal_conf.h system_stm32h5xx.c
  group App
    ../: boot.c boot.h header.h led.c led.h main.c net.c net.h shared_params.c shared_params.h timer.c timer.h startup_stm32h563xx.s
  group uIP
    ../../../../Source/third_party/uip/uip/: clock.h lc.h lc-addrlabels.h lc-switch.h pt.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uip-fw.c uip-fw.h uiplib.c uiplib.h uipopt.h
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
software components: CMSIS:CORE 4.3.0
