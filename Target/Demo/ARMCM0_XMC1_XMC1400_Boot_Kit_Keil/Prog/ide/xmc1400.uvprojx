# Keil uVision project xmc1400.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: XMC1404-Q064x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.12.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x10001000,0x32000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: demoprog_xmc1400
  AfterMake: fromelf --m32 --output=..\bin\demoprog_xmc1400.srec ..\bin\demoprog_xmc1400.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XMC1404_Q064x0200
  c include: ..\..\Prog;..\lib;..\lib\cmsis;..\lib\xmclib\inc
  memory RVCT4: ROM 0x10003000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\XMC1400x0200.sct
  group App
    ../: led.c led.h main.c startup_XMC1400.s boot.c boot.h header.h timer.c timer.h
  group Lib
    ../lib/: system_XMC1400.c system_XMC1400.h XMC1000_RomFunctionTable.h XMC1400.h
  group Lib/CMSIS
    ../lib/cmsis/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm0.h
  group Lib/XMClib
    ../lib/xmclib/inc/: xmc_acmp.h xmc_bccu.h xmc_can.h xmc_can_map.h xmc_ccu4.h xmc_ccu8.h xmc_common.h xmc_device.h xmc_eru.h xmc_flash.h xmc_gpio.h xmc_i2c.h xmc_i2s.h xmc_ledts.h xmc_pau.h xmc_posif.h xmc_posif_map.h xmc_prng.h xmc_rtc.h xmc_scu.h xmc_spi.h xmc_uart.h xmc_usic.h xmc_vadc.h xmc_vadc_map.h xmc_wdt.h xmc1_ccu4_map.h xmc1_ccu8_map.h xmc1_eru_map.h xmc1_flash.h xmc1_gpio.h xmc1_gpio_map.h xmc1_rtc.h xmc1_scu.h xmc1_usic_map.h
    ../lib/xmclib/src/: xmc_acmp.c xmc_bccu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_eru.c xmc_gpio.c xmc_i2c.c xmc_i2s.c xmc_ledts.c xmc_pau.c xmc_posif.c xmc_prng.c xmc_rtc.c xmc_spi.c xmc_uart.c xmc_usic.c xmc_vadc.c xmc_wdt.c xmc1_eru.c xmc1_flash.c xmc1_gpio.c xmc1_rtc.c xmc1_scu.c
