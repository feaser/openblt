# Keil uVision project xmc4700.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: XMC4700-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.14.0
  cpu: IRAM(0x20000000,0x3FFC0) IRAM2(0x1FFE8000,0x18000) IROM(0x08000000,0x200000) IROM2(0x0C000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demoprog_xmc4700
  AfterMake: fromelf --m32 --output=..\bin\demoprog_xmc4700.srec ..\bin\demoprog_xmc4700.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XMC4700_F144x2048 XMC_ETH_PHY_KSZ8081RNB
  c include: ..\..\Prog;..\lib;..\lib\cmsis;..\lib\xmclib\inc;..\lib\uip;..\..\..\..\Source\third_party\uip\uip;..\..\..\..\Source\third_party\uip\apps\dhcpc
  memory RVCT4: ROM 0x800c000 size 0x1f4000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  scatter file: ..\XMC4700x2048.sct
  group App
    ../: led.c led.h main.c startup_XMC4700.s boot.c boot.h header.h timer.c timer.h net.c net.h shared_params.c shared_params.h
  group Lib
    ../lib/: system_XMC4700.c system_XMC4700.h XMC4700.h
  group Lib/CMSIS
    ../lib/cmsis/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group Lib/XMClib
    ../lib/xmclib/inc/: xmc_can.h xmc_can_map.h xmc_ccu4.h xmc_ccu8.h xmc_common.h xmc_dac.h xmc_device.h xmc_dma.h xmc_dma_map.h xmc_dsd.h xmc_ebu.h xmc_ecat.h xmc_ecat_map.h xmc_eru.h xmc_eth_mac.h xmc_eth_mac_map.h xmc_eth_phy.h xmc_fce.h xmc_flash.h xmc_gpio.h xmc_hrpwm.h xmc_hrpwm_map.h xmc_i2c.h xmc_i2s.h xmc_ledts.h xmc_posif.h xmc_posif_map.h xmc_rtc.h xmc_scu.h xmc_sdmmc.h xmc_spi.h xmc_uart.h xmc_usbd.h xmc_usbd_regs.h xmc_usbh.h xmc_usic.h xmc_vadc.h xmc_vadc_map.h xmc_wdt.h xmc4_ccu4_map.h xmc4_ccu8_map.h xmc4_eru_map.h xmc4_flash.h xmc4_gpio.h xmc4_gpio_map.h xmc4_rtc.h xmc4_scu.h xmc4_usic_map.h
    ../lib/xmclib/src/: xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_dsd.c xmc_ebu.c xmc_ecat.c xmc_eru.c xmc_eth_mac.c xmc_eth_phy_dp83848.c xmc_eth_phy_ksz8031rnl.c xmc_eth_phy_ksz8081rnb.c xmc_fce.c xmc_gpio.c xmc_hrpwm.c xmc_i2c.c xmc_i2s.c xmc_ledts.c xmc_posif.c xmc_rtc.c xmc_sdmmc.c xmc_spi.c xmc_uart.c xmc_usbd.c xmc_usbh.c xmc_usic.c xmc_vadc.c xmc_wdt.c xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c
  group Lib/uip
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
  group third_party/uip
    ../../../../Source/third_party/uip/uip/: clock.h lc.h lc-addrlabels.h lc-switch.h pt.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
