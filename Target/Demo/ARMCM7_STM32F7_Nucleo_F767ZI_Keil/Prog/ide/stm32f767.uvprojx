# Keil uVision project stm32f767.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: demoprog_stm32f767
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32f767.srec ..\bin\demoprog_stm32f767.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ..\lib;..\lib\CMSIS\Device\ST\STM32F7xx\Include;..\lib\CMSIS\Include;..\lib\STM32F7xx_HAL_Driver\Inc;..\lib\STM32F7xx_HAL_Driver\Inc\Legacy;..\lib\uip;..\..\Prog;..\..\..\..\Source\third_party\uip\uip;..\..\..\..\Source\third_party\uip\apps\dhcpc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: ..\stm32f767.sct
  group Lib
    ../lib/CMSIS/Device/ST/STM32F7xx/Include/: stm32f7xx.h stm32f767xx.h system_stm32f7xx.h
    ../lib/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_cortex.h stm32f7xx_hal_def.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_exti.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_dma.h stm32f7xx_ll_exti.h stm32f7xx_ll_gpio.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_system.h stm32f7xx_ll_usart.h stm32f7xx_ll_utils.h
    ../lib/STM32F7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_exti.c stm32f7xx_hal_uart_ex.c
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h lan8742.c lan8742.h
    ../lib/: stm32f7xx_hal_conf.h system_stm32f7xx.c
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h tz_context.h
  group App
    ../: boot.c boot.h header.h led.c led.h main.c net.c net.h shared_params.c shared_params.h startup_stm32f767xx.s timer.c timer.h
  group uIP
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
    ../../../../Source/third_party/uip/uip/: clock.h lc.h lc-addrlabels.h lc-switch.h pt.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uip-fw.h uiplib.c uiplib.h uip-neighbor.h uipopt.h uip-split.h
