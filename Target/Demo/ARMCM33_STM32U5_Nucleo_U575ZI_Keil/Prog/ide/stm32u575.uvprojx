# Keil uVision project stm32u575.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: demoprog_stm32u575
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32u575.srec ..\bin\demoprog_stm32u575.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ..\..\Prog;..\lib;..\lib\CMSIS\Device\ST\STM32U5xx\Include;..\lib\CMSIS\Include;..\lib\STM32U5xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  scatter file: ..\stm32u575.sct
  group App
    ../: boot.c boot.h header.h led.c led.h main.c timer.c timer.h startup_stm32u575xx.s
  group Lib
    ../lib/CMSIS/Device/ST/STM32U5xx/Include/: stm32u5xx.h stm32u575xx.h system_stm32u5xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
    ../lib/STM32U5xx_HAL_Driver/Inc/: stm32u5xx_hal.h stm32u5xx_hal_cortex.h stm32u5xx_hal_def.h stm32u5xx_hal_dma.h stm32u5xx_hal_dma_ex.h stm32u5xx_hal_exti.h stm32u5xx_hal_fdcan.h stm32u5xx_hal_flash.h stm32u5xx_hal_flash_ex.h stm32u5xx_hal_gpio.h stm32u5xx_hal_gpio_ex.h stm32u5xx_hal_gtzc.h stm32u5xx_hal_i2c.h stm32u5xx_hal_i2c_ex.h stm32u5xx_hal_icache.h stm32u5xx_hal_pwr.h stm32u5xx_hal_pwr_ex.h stm32u5xx_hal_rcc.h stm32u5xx_hal_rcc_ex.h stm32u5xx_hal_tim.h stm32u5xx_hal_tim_ex.h stm32u5xx_hal_uart.h stm32u5xx_hal_uart_ex.h stm32u5xx_ll_bus.h stm32u5xx_ll_cortex.h stm32u5xx_ll_crs.h stm32u5xx_ll_dma.h stm32u5xx_ll_exti.h stm32u5xx_ll_gpio.h stm32u5xx_ll_icache.h stm32u5xx_ll_lpuart.h stm32u5xx_ll_pwr.h stm32u5xx_ll_rcc.h stm32u5xx_ll_system.h stm32u5xx_ll_usart.h stm32u5xx_ll_utils.h
    ../lib/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_fdcan.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
    ../lib/: stm32u5xx_hal_conf.h system_stm32u5xx.c
software components: CMSIS:CORE 4.3.0
