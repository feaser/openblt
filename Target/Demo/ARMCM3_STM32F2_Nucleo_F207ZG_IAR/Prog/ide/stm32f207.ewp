# IAR project stm32f207.ewp, settings and files
configuration stm32f207 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F207xx
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32F2xx\Include; ..\lib\STM32F2xx_HAL_Driver\Inc; ..\lib\uip; ..\..\..\..\Source\third_party\uip\uip; ..\..\..\..\Source\third_party\uip\apps\dhcpc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_stm32f207.srec
  ILINK.IlinkOutputFile: demoprog_stm32f207.out
  ILINK.IlinkIcfFile: ..\stm32f207xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Prog
    ../: boot.c boot.h header.h led.c led.h main.c net.c net.h shared_params.c shared_params.h startup_stm32f207xx.s timer.c timer.h
  group Prog/lib
    ../lib/: stm32f2xx_hal_conf.h system_stm32f2xx.c
  group Prog/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32F2xx/Include/: stm32f207xx.h stm32f2xx.h system_stm32f2xx.h
  group Prog/lib/HAL
    ../lib/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_uart.c
    ../lib/STM32F2xx_HAL_Driver/Inc/: stm32f2xx_hal.h stm32f2xx_hal_cortex.h stm32f2xx_hal_def.h stm32f2xx_hal_dma.h stm32f2xx_hal_dma_ex.h stm32f2xx_hal_eth.h stm32f2xx_hal_exti.h stm32f2xx_hal_flash.h stm32f2xx_hal_flash_ex.h stm32f2xx_hal_gpio.h stm32f2xx_hal_gpio_ex.h stm32f2xx_hal_pwr.h stm32f2xx_hal_pwr_ex.h stm32f2xx_hal_rcc.h stm32f2xx_hal_rcc_ex.h stm32f2xx_hal_uart.h
  group Prog/lib/uip
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
  group Prog/third_party/uip
    ../../../../Source/third_party/uip/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h pt.h uip-fw.c uip-fw.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
