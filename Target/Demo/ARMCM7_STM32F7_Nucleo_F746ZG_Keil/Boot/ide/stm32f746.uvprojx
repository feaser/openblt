# Keil uVision project stm32f746.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: openblt_stm32f746
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32f746.srec ..\bin\openblt_stm32f746.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_FULL_LL_DRIVER
  c misc: --diag_suppress=111
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32F7xx\Include;..\lib\CMSIS\Include;..\lib\STM32F7xx_HAL_Driver\Inc;..\lib\STM32F7xx_HAL_Driver\Inc\Legacy;..\lib\STM32_USB_Device_Library\Core\Inc;..\..\..\..\Source;..\..\..\..\Source\ARMCM7_STM32F7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: ..\stm32f746.sct
  group Lib
    ../lib/: stm32f7xx_hal_conf.h system_stm32f7xx.c
    ../lib/CMSIS/Device/ST/STM32F7xx/Include/: stm32f7xx.h stm32f746xx.h system_stm32f7xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm7.h tz_context.h
    ../lib/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../lib/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_can.h stm32f7xx_hal_cortex.h stm32f7xx_hal_def.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_exti.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_dma.h stm32f7xx_ll_exti.h stm32f7xx_ll_gpio.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_system.h stm32f7xx_ll_usart.h stm32f7xx_ll_usb.h stm32f7xx_ll_utils.h
    ../lib/STM32F7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_dma.c stm32f7xx_ll_exti.c stm32f7xx_ll_gpio.c stm32f7xx_ll_rcc.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group App
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32f746xx.s usbd_bulk.c usbd_bulk.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h
  group Core
    ../../../../Source/: backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h timer.h usb.h xcp.c xcp.h rs232.h asserts.c asserts.h
    ../../../../Source/ARMCM7_STM32F7/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h usb.c rs232.c
    ../../../../Source/ARMCM7_STM32F7/Keil/: cpu_comp.c
