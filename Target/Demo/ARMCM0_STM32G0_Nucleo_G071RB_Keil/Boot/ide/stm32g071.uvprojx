# Keil uVision project stm32g071.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: openblt_stm32g071
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32g071.srec ..\bin\openblt_stm32g071.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32G071xx
  c misc: --diag_suppress=111
  c include: ..\lib;..\lib\CMSIS\Device\ST\STM32G0xx\Include;..\lib\CMSIS\Include;..\lib\STM32G0xx_HAL_Driver\Inc;..\lib\STM32G0xx_HAL_Driver\Inc\Legacy;..\..\Boot;..\..\..\..\Source;..\..\..\..\Source\ARMCM0_STM32G0;..\..\..\..\Source\ARMCM0_STM32G0\Keil
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\STM32G071.sct
  group Lib
    ../lib/CMSIS/Device/ST/STM32G0xx/Include/: stm32g0xx.h stm32g071xx.h system_stm32g0xx.h
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../lib/: stm32g0xx_hal_conf.h system_stm32g0xx.c
    ../lib/STM32G0xx_HAL_Driver/Inc/: stm32g0xx_hal.h stm32g0xx_hal_adc.h stm32g0xx_hal_adc_ex.h stm32g0xx_hal_cortex.h stm32g0xx_hal_def.h stm32g0xx_hal_dma.h stm32g0xx_hal_dma_ex.h stm32g0xx_hal_exti.h stm32g0xx_hal_flash.h stm32g0xx_hal_flash_ex.h stm32g0xx_hal_gpio.h stm32g0xx_hal_gpio_ex.h stm32g0xx_hal_pwr.h stm32g0xx_hal_pwr_ex.h stm32g0xx_hal_rcc.h stm32g0xx_hal_rcc_ex.h stm32g0xx_hal_tim.h stm32g0xx_hal_tim_ex.h stm32g0xx_ll_adc.h stm32g0xx_ll_bus.h stm32g0xx_ll_cortex.h stm32g0xx_ll_dma.h stm32g0xx_ll_dmamux.h stm32g0xx_ll_exti.h stm32g0xx_ll_gpio.h stm32g0xx_ll_pwr.h stm32g0xx_ll_rcc.h stm32g0xx_ll_system.h stm32g0xx_ll_usart.h stm32g0xx_ll_utils.h
    ../lib/STM32G0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
  group App
    ../: led.c led.h main.c startup_stm32g071xx.s blt_conf.h hooks.c
  group Core
    ../../../../Source/: backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h timer.h usb.h xcp.c xcp.h rs232.h asserts.c asserts.h
    ../../../../Source/ARMCM0_STM32G0/: cpu.c flash.c flash.h nvm.c timer.c types.h rs232.c
    ../../../../Source/ARMCM0_STM32G0/Keil/: cpu_comp.c
