# Keil uVision project stm32g071.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demoprog_stm32g071
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32g071.srec ..\bin\demoprog_stm32g071.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G071xx
  c misc: --diag_suppress=111
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32G0xx\Include;..\lib\CMSIS\Include;..\lib\STM32G0xx_HAL_Driver\Inc;..\lib\STM32G0xx_HAL_Driver\Inc\Legacy;..\..\Prog
  memory RVCT4: ROM 0x8002800 size 0x1d800
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\STM32G071.sct
  group Lib
    ../lib/: stm32g0xx_hal_conf.h system_stm32g0xx.c
    ../lib/CMSIS/Device/ST/STM32G0xx/Include/: stm32g0xx.h stm32g071xx.h system_stm32g0xx.h
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    ../lib/STM32G0xx_HAL_Driver/Inc/: stm32g0xx_hal.h stm32g0xx_hal_cortex.h stm32g0xx_hal_def.h stm32g0xx_hal_dma.h stm32g0xx_hal_dma_ex.h stm32g0xx_hal_flash.h stm32g0xx_hal_flash_ex.h stm32g0xx_hal_gpio.h stm32g0xx_hal_gpio_ex.h stm32g0xx_hal_pwr.h stm32g0xx_hal_pwr_ex.h stm32g0xx_hal_rcc.h stm32g0xx_hal_rcc_ex.h stm32g0xx_hal_tim.h stm32g0xx_hal_tim_ex.h stm32g0xx_hal_uart.h stm32g0xx_hal_uart_ex.h
    ../lib/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group App
    ../: boot.c boot.h header.h led.c led.h main.c timer.c timer.h startup_stm32g071xx.s
