# Keil uVision project stm32f103.uvprojx, settings and files
target Target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: openblt_olimex_stm32p103
  AfterMake: fromelf --m32 --output=..\bin\openblt_olimex_stm32p103.srec ..\bin\openblt_olimex_stm32p103.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,reset_handler=Reset_Handler
  c misc: --diag_suppress=111 --diag_suppress=550
  c include: ..\lib\CMSIS\CM3\CoreSupport;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\fatfs;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\STM32F10x_StdPeriph_Driver\src;..\lib\STM32F10x_StdPeriph_Driver;..\..\..\..\Source;..\..\..\..\Source\ARMCM3_STM32;..\..\..\..\Source\ARMCM3_STM32\Keil;..\..\..\..\Source\third_party\fatfs\src;..\..\Boot
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\..\..\Source\ARMCM3_STM32\Keil\memory.x
  group Lib
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../lib/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_usart.h
    ../lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
    ../lib/STM32F10x_StdPeriph_Driver/: stm32f10x_conf.h
    ../lib/fatfs/: ffconf.h mmc.c
  group App
    ../: blt_conf.h hooks.c main.c
  group Core
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h nvm.h plausibility.h timer.h uart.h xcp.c xcp.h
    ../../../../Source/ARMCM3_STM32/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h uart.c usb.c
    ../../../../Source/ARMCM3_STM32/Keil/: startup_stm32f10x_md.s
    ../../../../Source/third_party/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/third_party/fatfs/src/option/: unicode.c
