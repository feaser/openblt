# Keil uVision project stm32f103.uvprojx, settings and files
target Target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demoprog_olimex_stm32p103
  AfterMake: fromelf --m32 --output=..\bin\demoprog_olimex_stm32p103.srec ..\bin\demoprog_olimex_stm32p103.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\..\Boot;..\lib\stdperiphlib;..\lib\stdperiphlib\CMSIS\CM3\CoreSupport;..\lib\stdperiphlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\stdperiphlib\STM32F10x_StdPeriph_Driver\inc;..\lib\stdperiphlib\STM32F10x_StdPeriph_Driver\src;..\..\Prog
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\memory.x
  group Lib
    ../lib/stdperiphlib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../lib/stdperiphlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../lib/stdperiphlib/: stm32f10x_conf.h
    ../lib/stdperiphlib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../lib/stdperiphlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group App
    ../: boot.c boot.h header.h irq.c irq.h led.c led.h main.c startup_stm32f10x_md.s timer.c timer.h
