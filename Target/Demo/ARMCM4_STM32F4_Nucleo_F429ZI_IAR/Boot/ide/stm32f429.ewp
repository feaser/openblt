# IAR project stm32f429.ewp, settings and files
configuration stm32f429 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32F4xx\Include; ..\lib\STM32F4xx_HAL_Driver\Inc; ..\lib\STM32F4xx_HAL_Driver\Inc\Legacy; ..\lib\STM32_USB_Device_Library\Core\Inc; ..\lib\uip; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM4_STM32F4; ..\..\..\..\Source\third_party\uip\uip; ..\..\..\..\Source\third_party\uip\apps\dhcpc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32f429.srec
  ILINK.IlinkOutputFile: openblt_stm32f429.out
  ILINK.IlinkIcfFile: ..\stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c shared_params.c shared_params.h startup_stm32f429xx.s usbd_bulk.c usbd_bulk.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h
  group Boot/lib
    ../lib/: stm32f4xx_hal_conf.h system_stm32f4xx.c
  group Boot/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32F4xx/Include/: stm32f429xx.h stm32f4xx.h system_stm32f4xx.h
  group Boot/lib/HAL
    ../lib/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
    ../lib/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_can.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_eth.h stm32f4xx_hal_exti.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_dma.h stm32f4xx_ll_exti.h stm32f4xx_ll_gpio.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_system.h stm32f4xx_ll_usart.h stm32f4xx_ll_usb.h stm32f4xx_ll_utils.h
  group Boot/lib/uip
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
  group Boot/lib/USB_Device
    ../lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../lib/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h mb.c mb.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM4_STM32F4
    ../../../../Source/ARMCM4_STM32F4/: can.c cpu.c flash.c flash.h mbrtu.c nvm.c rs232.c timer.c types.h usb.c
  group Source/ARMCM4_STM32F4/IAR
    ../../../../Source/ARMCM4_STM32F4/IAR/: cpu_comp.c
  group Source/third_party/uip
    ../../../../Source/third_party/uip/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h pt.h uip-fw.c uip-fw.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uipopt.h
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
