# Keil uVision project stm32f405.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: demoprog_olimex_stm32p405
  AfterMake: fromelf --m32 --output=..\bin\demoprog_olimex_stm32p405.srec ..\bin\demoprog_olimex_stm32p405.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c misc: --diag_suppress=111
  c include: ..\..\Prog;..\lib;..\lib\CMSIS\Device\ST\STM32F4xx\Include;..\lib\CMSIS\Include;..\lib\STM32F4xx_HAL_Driver\Inc;..\lib\STM32F4xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\olimex_stm32p405.sct
  group App
    ../: boot.c boot.h header.h led.c led.h main.c timer.c timer.h startup_stm32f405xx.s
  group Lib
    ../lib/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h stm32f405xx.h system_stm32f4xx.h
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../lib/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_can.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h
    ../lib/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ../lib/: stm32f4xx_hal_conf.h system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
