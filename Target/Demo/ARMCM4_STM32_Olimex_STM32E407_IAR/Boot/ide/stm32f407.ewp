# IAR project stm32f407.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; HSE_VALUE=12000000
  ICCARM.CCIncludePath2: ..; ..\lib\stdperiphlib; ..\lib\stdperiphlib\CMSIS\Device\ST\STM32F4xx\Include; ..\lib\stdperiphlib\CMSIS\Include; ..\lib\fatfs; ..\lib\stdperiphlib\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM4_STM32; ..\..\..\..\Source\fatfs\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openbtl_olimex_stm32e407.srec
  ILINK.IlinkOutputFile: openbtl_olimex_stm32e407.out
  ILINK.IlinkIcfFile: ..\..\..\..\Source\ARMCM4_STM32\IAR\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Boot
    ../: blt_conf.h hooks.c main.c
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/stdperiphlib
    ../lib/stdperiphlib/CMSIS/Include/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../lib/stdperiphlib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../lib/stdperiphlib/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ../lib/stdperiphlib/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../lib/stdperiphlib/: stm32f4xx_conf.h
    ../lib/stdperiphlib/CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h com.c com.h cop.c cop.h file.c file.h plausibility.h xcp.c xcp.h
  group Source/ARMCM4_STM32
    ../../../../Source/ARMCM4_STM32/: can.c can.h cpu.c cpu.h flash.c flash.h nvm.c nvm.h timer.c timer.h types.h uart.c uart.h
  group Source/ARMCM4_STM32/IAR
    ../../../../Source/ARMCM4_STM32/IAR/: cstart.s vectors.c
  group Source/fatfs
    ../../../../Source/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/fatfs/src/option/: unicode.c
