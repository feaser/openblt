# IAR project stm32f103.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\ARMCM3_STM32F1; ..\..\..\..\Source\ARMCM3_STM32F1\IAR; ..; ..\lib\stdperiphlib; ..\lib\stdperiphlib\CMSIS\CM3\CoreSupport; ..\lib\stdperiphlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\lib\stdperiphlib\STM32F10x_StdPeriph_Driver\inc; ..\lib\stdperiphlib\STM32F10x_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_nucleo_stm32f103rb.srec
  ILINK.IlinkOutputFile: openblt_nucleo_stm32f103rb.out
  ILINK.IlinkIcfFile: ..\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Boot
    ../: blt_conf.h flash_layout.c hooks.c led.c led.h main.c startup_stm32f103xb.s
  group Boot/lib
    ../lib/stdperiphlib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../lib/stdperiphlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../lib/stdperiphlib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../lib/stdperiphlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../lib/stdperiphlib/: stm32f10x_conf.h
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h timer.h uart.h usb.h xcp.c xcp.h
  group Source/ARMCM3_STM32F1
    ../../../../Source/ARMCM3_STM32F1/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h uart.c usb.c
  group Source/ARMCM3_STM32F1/IAR
    ../../../../Source/ARMCM3_STM32F1/IAR/: cpu_comp.c
