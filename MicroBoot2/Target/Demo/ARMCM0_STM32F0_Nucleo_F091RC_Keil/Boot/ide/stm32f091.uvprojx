# Keil uVision project stm32f091.uvprojx, settings and files
target Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: openblt_stm32f091
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32f091.srec ..\bin\openblt_stm32f091.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F091,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\lib;..\lib\cmsis;..\lib\SPL\inc;..\..\Boot;..\..\..\..\Source;..\..\..\..\Source\ARMCM0_STM32F0;..\..\..\..\Source\ARMCM0_STM32F0\Keil
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\STM32F091.sct
  group Lib
    ../lib/: stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
    ../lib/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cmFunc.h core_cmInstr.h
    ../lib/SPL/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ../lib/SPL/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group App
    ../: led.c led.h main.c startup_stm32f091.s blt_conf.h hooks.c
  group Core
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h timer.h uart.h usb.h xcp.c xcp.h
    ../../../../Source/ARMCM0_STM32F0/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h uart.c
    ../../../../Source/ARMCM0_STM32F0/Keil/: cpu_comp.c
