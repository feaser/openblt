# IAR project stm32f091.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F091; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\lib; ..\lib\cmsis; ..\lib\SPL\inc; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_stm32f091.srec
  ILINK.IlinkOutputFile: demoprog_stm32f091.out
  ILINK.IlinkIcfFile: ..\stm32f091_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Prog
    ../: boot.c boot.h header.h led.c led.h main.c startup_stm32f091.s timer.c timer.h
  group Prog/lib
    ../lib/: stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
  group Prog/lib/cmsis
    ../lib/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cmFunc.h core_cmInstr.h
  group Prog/lib/SPL/inc
    ../lib/SPL/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group Prog/lib/SPL/src
    ../lib/SPL/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
