# IAR project stm32f0.ewp, settings and files
configuration stm32f0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; FALSE=0; TRUE=1
  ICCARM.CCIncludePath2: ..\lib; ..\lib\cmsis; ..\lib\SPL\inc; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM0_STM32F0; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32f051.srec
  ILINK.IlinkOutputFile: openblt_stm32f051.out
  ILINK.IlinkIcfFile: ..\stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../lib/: stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
  group lib/cmsis
    ../lib/cmsis/: arm_common_tables.h arm_math.h core_cm0.h core_cmFunc.h core_cmInstr.h
  group lib/SPL
    ../lib/SPL/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ../lib/SPL/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group src
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32f0xx.s
  group src/core
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h timer.h uart.h usb.h xcp.c xcp.h
    ../../../../Source/ARMCM0_STM32F0/: cpu.c flash.c flash.h nvm.c timer.c types.h uart.c
    ../../../../Source/ARMCM0_STM32F0/IAR/: cpu_comp.c
