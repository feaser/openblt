# Keil uVision project stm32g0b1.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G0B1RETx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: demoprog_stm32g0b1
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32g0b1.srec ..\bin\demoprog_stm32g0b1.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c misc: --diag_suppress=111
  c include: ..\..\Prog;..\lib;..\lib\CMSIS\Device\ST\STM32G0xx\Include;..\lib\CMSIS\Include;..\lib\STM32G0xx_HAL_Driver\Inc;..\lib\STM32G0xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: ..\STM32G0B1.sct
  group Lib
    ../lib/: stm32g0xx_hal_conf.h system_stm32g0xx.c
    ../lib/CMSIS/Device/ST/STM32G0xx/Include/: stm32g0b1xx.h stm32g0xx.h system_stm32g0xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm0plus.h tz_context.h
    ../lib/STM32G0xx_HAL_Driver/Inc/: stm32g0xx_hal.h stm32g0xx_hal_cortex.h stm32g0xx_hal_def.h stm32g0xx_hal_dma.h stm32g0xx_hal_dma_ex.h stm32g0xx_hal_exti.h stm32g0xx_hal_fdcan.h stm32g0xx_hal_flash.h stm32g0xx_hal_flash_ex.h stm32g0xx_hal_gpio.h stm32g0xx_hal_gpio_ex.h stm32g0xx_hal_pwr.h stm32g0xx_hal_pwr_ex.h stm32g0xx_hal_rcc.h stm32g0xx_hal_rcc_ex.h stm32g0xx_hal_tim.h stm32g0xx_hal_tim_ex.h stm32g0xx_hal_uart.h stm32g0xx_hal_uart_ex.h stm32g0xx_ll_dma.h stm32g0xx_ll_dmamux.h stm32g0xx_ll_rcc.h
    ../lib/STM32G0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c
  group App
    ../: boot.c boot.h header.h led.c led.h main.c timer.c timer.h startup_stm32g0b1xx.s
software components: CMSIS:CORE 4.3.0
