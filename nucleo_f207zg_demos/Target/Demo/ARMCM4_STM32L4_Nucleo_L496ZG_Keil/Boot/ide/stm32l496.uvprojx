# Keil uVision project stm32l496.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2003FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: openblt_stm32l496
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32l496.srec ..\bin\openblt_stm32l496.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L496xx
  c misc: --diag_suppress=111
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32L4xx\Include;..\lib\CMSIS\Include;..\lib\STM32_USB_Device_Library\Core\Inc;..\lib\STM32L4xx_HAL_Driver\Inc;..\lib\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\..\Source;..\..\..\..\Source\ARMCM4_STM32L4;..\..\..\..\Source\ARMCM4_STM32L4\Keil
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\stm32l496.sct
  group Lib
    ../lib/CMSIS/Device/ST/STM32L4xx/Include/: stm32l4xx.h stm32l496xx.h system_stm32l4xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm4.h tz_context.h
    ../lib/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../lib/STM32L4xx_HAL_Driver/Inc/: stm32l4xx_hal.h stm32l4xx_hal_cortex.h stm32l4xx_hal_def.h stm32l4xx_hal_dma.h stm32l4xx_hal_dma_ex.h stm32l4xx_hal_exti.h stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.h stm32l4xx_ll_bus.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crs.h stm32l4xx_ll_dma.h stm32l4xx_ll_dmamux.h stm32l4xx_ll_exti.h stm32l4xx_ll_gpio.h stm32l4xx_ll_lpuart.h stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.h stm32l4xx_ll_system.h stm32l4xx_ll_usb.h stm32l4xx_ll_utils.h
    ../lib/STM32L4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_rcc.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
    ../lib/: stm32l4xx_hal_conf.h system_stm32l4xx.c
  group App
    ../: blt_conf.h flash_layout.c hooks.c led.c led.h main.c usbd_bulk.c usbd_bulk.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h startup_stm32l496xx.s
  group Core
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
    ../../../../Source/ARMCM4_STM32L4/: can.c cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h usb.c
    ../../../../Source/ARMCM4_STM32L4/Keil/: cpu_comp.c
software components: CMSIS:CORE 4.3.0
