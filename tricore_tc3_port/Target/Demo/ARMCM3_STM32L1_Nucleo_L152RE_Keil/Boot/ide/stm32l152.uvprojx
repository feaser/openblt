# Keil uVision project stm32l152.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L152RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: openblt_stm32l152
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32l152.srec ..\bin\openblt_stm32l152.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L152xE
  c misc: --diag_suppress=111
  c include: ..\lib;..\lib\CMSIS\Device\ST\STM32L1xx\Include;..\lib\CMSIS\Include;..\lib\STM32L1xx_HAL_Driver\Inc;..\lib\STM32L1xx_HAL_Driver\Inc\Legacy;..\..\Boot;..\..\..\..\Source;..\..\..\..\Source\ARMCM3_STM32L1;..\..\..\..\Source\ARMCM3_STM32L1\Keil
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  scatter file: ..\stm32l152.sct
  group Lib
    ../lib/: stm32l1xx_hal_conf.h system_stm32l1xx.c
    ../lib/CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h stm32l152xe.h system_stm32l1xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_cm23.h core_cm33.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    ../lib/STM32L1xx_HAL_Driver/Inc/: stm32l1xx_hal.h stm32l1xx_hal_cortex.h stm32l1xx_hal_def.h stm32l1xx_hal_dma.h stm32l1xx_hal_exti.h stm32l1xx_hal_flash.h stm32l1xx_hal_flash_ex.h stm32l1xx_hal_flash_ramfunc.h stm32l1xx_hal_gpio.h stm32l1xx_hal_gpio_ex.h stm32l1xx_hal_pwr.h stm32l1xx_hal_pwr_ex.h stm32l1xx_hal_rcc.h stm32l1xx_hal_rcc_ex.h stm32l1xx_hal_tim.h stm32l1xx_hal_tim_ex.h stm32l1xx_ll_bus.h stm32l1xx_ll_cortex.h stm32l1xx_ll_dma.h stm32l1xx_ll_exti.h stm32l1xx_ll_gpio.h stm32l1xx_ll_pwr.h stm32l1xx_ll_rcc.h stm32l1xx_ll_system.h stm32l1xx_ll_usart.h stm32l1xx_ll_utils.h
    ../lib/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_exti.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_gpio.c stm32l1xx_ll_rcc.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
  group App
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32l152xe.s
  group Core
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
    ../../../../Source/ARMCM3_STM32L1/: cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h
    ../../../../Source/ARMCM3_STM32L1/Keil/: cpu_comp.c
