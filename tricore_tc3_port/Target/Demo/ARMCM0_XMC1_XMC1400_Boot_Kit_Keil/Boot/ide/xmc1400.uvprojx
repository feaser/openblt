# Keil uVision project xmc1400.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: XMC1404-Q064x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.12.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x10001000,0x32000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: openblt_xmc1400
  AfterMake: fromelf --m32 --output=..\bin\openblt_xmc1400.srec ..\bin\openblt_xmc1400.axf
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XMC1404_Q064x0200
  c misc: --diag_suppress=111
  c include: ..\..\Boot;..\lib;..\lib\cmsis;..\lib\xmclib\inc;..\..\..\..\Source;..\..\..\..\Source\ARMCM0_XMC1
  memory RVCT4: ROM 0x10001000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ../: blt_conf.h hooks.c led.c led.h main.c startup_XMC1400.s
  group Lib
    ../lib/: system_XMC1400.c system_XMC1400.h XMC1000_RomFunctionTable.h XMC1400.h
  group Lib/CMSIS
    ../lib/cmsis/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm0.h
  group Lib/XMClib
    ../lib/xmclib/inc/: xmc_acmp.h xmc_bccu.h xmc_can.h xmc_can_map.h xmc_ccu4.h xmc_ccu8.h xmc_common.h xmc_dac.h xmc_device.h xmc_dma.h xmc_dma_map.h xmc_dsd.h xmc_ebu.h xmc_ecat.h xmc_ecat_map.h xmc_eru.h xmc_eth_mac.h xmc_eth_mac_map.h xmc_eth_phy.h xmc_fce.h xmc_flash.h xmc_gpio.h xmc_hrpwm.h xmc_hrpwm_map.h xmc_i2c.h xmc_i2s.h xmc_ledts.h xmc_math.h xmc_pau.h xmc_posif.h xmc_posif_map.h xmc_prng.h xmc_rtc.h xmc_scu.h xmc_sdmmc.h xmc_spi.h xmc_uart.h xmc_usbd.h xmc_usbd_regs.h xmc_usbh.h xmc_usic.h xmc_vadc.h xmc_vadc_map.h xmc_wdt.h xmc1_ccu4_map.h xmc1_ccu8_map.h xmc1_eru_map.h xmc1_flash.h xmc1_gpio.h xmc1_gpio_map.h xmc1_rtc.h xmc1_scu.h xmc1_usic_map.h xmc4_ccu4_map.h xmc4_ccu8_map.h xmc4_eru_map.h xmc4_flash.h xmc4_gpio.h xmc4_gpio_map.h xmc4_rtc.h xmc4_scu.h xmc4_usic_map.h
    ../lib/xmclib/src/: xmc_acmp.c xmc_bccu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_dsd.c xmc_ebu.c xmc_ecat.c xmc_eru.c xmc_eth_mac.c xmc_eth_phy_dp83848.c xmc_eth_phy_ksz8031rnl.c xmc_eth_phy_ksz8081rnb.c xmc_fce.c xmc_gpio.c xmc_hrpwm.c xmc_i2c.c xmc_i2s.c xmc_ledts.c xmc_math.c xmc_pau.c xmc_posif.c xmc_prng.c xmc_rtc.c xmc_sdmmc.c xmc_spi.c xmc_uart.c xmc_usbd.c xmc_usbh.c xmc_usic.c xmc_vadc.c xmc_wdt.c xmc1_eru.c xmc1_flash.c xmc1_gpio.c xmc1_rtc.c xmc1_scu.c xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c
  group Core
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Core/ARMCM0_XMC1
    ../../../../Source/ARMCM0_XMC1/: can.c cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h
    ../../../../Source/ARMCM0_XMC1/Keil/: cpu_comp.c
