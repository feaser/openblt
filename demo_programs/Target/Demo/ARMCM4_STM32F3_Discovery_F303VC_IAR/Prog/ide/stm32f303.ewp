# IAR project stm32f303.ewp, settings and files
configuration stm32f303 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32F3xx\Include; ..\lib\STM32F3xx_HAL_Driver\Inc; ..\lib\STM32F3xx_HAL_Driver\Inc\Legacy
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_stm32f303.srec
  ILINK.IlinkOutputFile: demoprog_stm32f303.out
  ILINK.IlinkIcfFile: ..\stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Prog
    ../: header.h led.c led.h main.c startup_stm32f303xc.s timer.c timer.h
  group Prog/lib
    ../lib/: stm32f3xx_hal_conf.h system_stm32f3xx.c
  group Prog/lib/CMSIS
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../lib/CMSIS/Device/ST/STM32F3xx/Include/: stm32f303xc.h stm32f3xx.h system_stm32f3xx.h
  group Prog/lib/HAL
    ../lib/STM32F3xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
    ../lib/STM32F3xx_HAL_Driver/Inc/: stm32f3xx_hal.h stm32f3xx_hal_cortex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h
