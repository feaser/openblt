# IAR project stm32l152.ewp, settings and files
configuration stm32l152 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32L152xE
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32L1xx\Include; ..\lib\STM32L1xx_HAL_Driver\Inc; ..\lib\STM32L1xx_HAL_Driver\Inc\Legacy; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM3_STM32L1
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32l152.srec
  ILINK.IlinkOutputFile: openblt_stm32l152.out
  ILINK.IlinkIcfFile: ..\stm32l152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32l152xe.s
  group Boot/lib
    ../lib/: stm32l1xx_hal_conf.h system_stm32l1xx.c
  group Boot/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32L1xx/Include/: stm32l152xe.h stm32l1xx.h system_stm32l1xx.h
  group Boot/lib/HAL_Driver
    ../lib/STM32L1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_exti.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_gpio.c stm32l1xx_ll_rcc.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
    ../lib/STM32L1xx_HAL_Driver/Inc/: stm32l1xx_hal.h stm32l1xx_hal_cortex.h stm32l1xx_hal_def.h stm32l1xx_hal_dma.h stm32l1xx_hal_exti.h stm32l1xx_hal_flash.h stm32l1xx_hal_flash_ex.h stm32l1xx_hal_flash_ramfunc.h stm32l1xx_hal_gpio.h stm32l1xx_hal_gpio_ex.h stm32l1xx_hal_pwr.h stm32l1xx_hal_pwr_ex.h stm32l1xx_hal_rcc.h stm32l1xx_hal_rcc_ex.h stm32l1xx_hal_tim.h stm32l1xx_hal_tim_ex.h stm32l1xx_ll_bus.h stm32l1xx_ll_cortex.h stm32l1xx_ll_dma.h stm32l1xx_ll_exti.h stm32l1xx_ll_gpio.h stm32l1xx_ll_pwr.h stm32l1xx_ll_rcc.h stm32l1xx_ll_system.h stm32l1xx_ll_usart.h stm32l1xx_ll_utils.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM3_STM32L1
    ../../../../Source/ARMCM3_STM32L1/: cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h
  group Source/ARMCM3_STM32L1/IAR
    ../../../../Source/ARMCM3_STM32L1/IAR/: cpu_comp.c
