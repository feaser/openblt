# IAR project stm32g431.ewp, settings and files
configuration Prog (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431RB ST STM32G431RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G431xx
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32G4xx\Include; ..\lib\STM32G4xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_stm32g431.srec
  ILINK.IlinkOutputFile: demoprog_stm32g431.out
  ILINK.IlinkIcfFile: ..\stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Prog
    ../: boot.c boot.h header.h led.c led.h main.c startup_stm32g431xx.s timer.c timer.h
  group Prog/lib
    ../lib/: stm32g4xx_hal_conf.h system_stm32g4xx.c
  group Prog/lib/CMSIS
    ../lib/CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h tz_context.h
    ../lib/CMSIS/Device/ST/STM32G4xx/Include/: stm32g431xx.h stm32g4xx.h system_stm32g4xx.h
  group Prog/lib/HAL_Driver
    ../lib/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
    ../lib/STM32G4xx_HAL_Driver/Inc/: stm32g4xx_hal.h stm32g4xx_hal_cortex.h stm32g4xx_hal_def.h stm32g4xx_hal_dma.h stm32g4xx_hal_dma_ex.h stm32g4xx_hal_exti.h stm32g4xx_hal_fdcan.h stm32g4xx_hal_flash.h stm32g4xx_hal_flash_ex.h stm32g4xx_hal_flash_ramfunc.h stm32g4xx_hal_gpio.h stm32g4xx_hal_gpio_ex.h stm32g4xx_hal_pwr.h stm32g4xx_hal_pwr_ex.h stm32g4xx_hal_rcc.h stm32g4xx_hal_rcc_ex.h stm32g4xx_hal_tim.h stm32g4xx_hal_tim_ex.h stm32g4xx_hal_uart.h stm32g4xx_hal_uart_ex.h stm32g4xx_ll_bus.h stm32g4xx_ll_cortex.h stm32g4xx_ll_crs.h stm32g4xx_ll_dma.h stm32g4xx_ll_dmamux.h stm32g4xx_ll_exti.h stm32g4xx_ll_gpio.h stm32g4xx_ll_lpuart.h stm32g4xx_ll_pwr.h stm32g4xx_ll_rcc.h stm32g4xx_ll_system.h stm32g4xx_ll_usart.h stm32g4xx_ll_utils.h
