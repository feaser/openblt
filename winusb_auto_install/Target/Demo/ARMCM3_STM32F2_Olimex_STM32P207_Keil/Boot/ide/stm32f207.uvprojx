# Keil uVision project stm32f207.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F207ZETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: openblt_stm32f207
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32f207.srec ..\bin\openblt_stm32f207.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F207xx
  c misc: --diag_suppress=111
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32F2xx\Include;..\lib\CMSIS\Include;..\lib\fatfs;..\lib\STM32F2xx_HAL_Driver\Inc;..\lib\STM32F2xx_HAL_Driver\Inc\Legacy;..\..\..\..\Source;..\..\..\..\Source\ARMCM3_STM32F2;..\..\..\..\Source\ARMCM3_STM32F2\Keil;..\..\..\..\Source\third_party\fatfs\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\stm32f207.sct
  group Lib
    ../lib/CMSIS/Device/ST/STM32F2xx/Include/: stm32f2xx.h stm32f207xx.h system_stm32f2xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm3.h tz_context.h
    ../lib/fatfs/: ffconf.h mmc.c
    ../lib/STM32F2xx_HAL_Driver/Inc/: stm32f2xx_hal.h stm32f2xx_hal_can.h stm32f2xx_hal_cortex.h stm32f2xx_hal_def.h stm32f2xx_hal_dma.h stm32f2xx_hal_dma_ex.h stm32f2xx_hal_exti.h stm32f2xx_hal_flash.h stm32f2xx_hal_flash_ex.h stm32f2xx_hal_gpio.h stm32f2xx_hal_gpio_ex.h stm32f2xx_hal_pwr.h stm32f2xx_hal_pwr_ex.h stm32f2xx_hal_rcc.h stm32f2xx_hal_rcc_ex.h stm32f2xx_hal_tim.h stm32f2xx_hal_tim_ex.h stm32f2xx_ll_bus.h stm32f2xx_ll_cortex.h stm32f2xx_ll_dma.h stm32f2xx_ll_exti.h stm32f2xx_ll_gpio.h stm32f2xx_ll_pwr.h stm32f2xx_ll_rcc.h stm32f2xx_ll_spi.h stm32f2xx_ll_system.h stm32f2xx_ll_usart.h stm32f2xx_ll_utils.h
    ../lib/STM32F2xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_ll_dma.c stm32f2xx_ll_exti.c stm32f2xx_ll_gpio.c stm32f2xx_ll_rcc.c stm32f2xx_ll_spi.c stm32f2xx_ll_usart.c stm32f2xx_ll_utils.c
    ../lib/: stm32f2xx_hal_conf.h system_stm32f2xx.c
  group App
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32f207xx.s
  group Core
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
    ../../../../Source/third_party/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/third_party/fatfs/src/option/: unicode.c
    ../../../../Source/ARMCM3_STM32F2/: can.c cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h
    ../../../../Source/ARMCM3_STM32F2/Keil/: cpu_comp.c
software components: CMSIS:CORE 4.3.0
