# Keil uVision project stm32f207.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F207ZGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: demoprog_stm32f207
  AfterMake: fromelf --m32 --output=..\bin\demoprog_stm32f207.srec ..\bin\demoprog_stm32f207.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --diag_suppress=111
  c include: ..\..\Prog;..\lib;..\lib\CMSIS\Device\ST\STM32F2xx\Include;..\lib\CMSIS\Include;..\lib\STM32F2xx_HAL_Driver\Inc;..\lib\uip;..\..\..\..\Source\third_party\uip\uip;..\..\..\..\Source\third_party\uip\apps\dhcpc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: ..\stm32f207.sct
  group Lib
    ../lib/CMSIS/Device/ST/STM32F2xx/Include/: stm32f2xx.h stm32f207xx.h system_stm32f2xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm3.h tz_context.h
    ../lib/STM32F2xx_HAL_Driver/Inc/: stm32f2xx_hal.h stm32f2xx_hal_cortex.h stm32f2xx_hal_def.h stm32f2xx_hal_dma.h stm32f2xx_hal_dma_ex.h stm32f2xx_hal_eth.h stm32f2xx_hal_exti.h stm32f2xx_hal_flash.h stm32f2xx_hal_flash_ex.h stm32f2xx_hal_gpio.h stm32f2xx_hal_gpio_ex.h stm32f2xx_hal_pwr.h stm32f2xx_hal_pwr_ex.h stm32f2xx_hal_rcc.h stm32f2xx_hal_rcc_ex.h stm32f2xx_hal_tim.h stm32f2xx_hal_tim_ex.h stm32f2xx_hal_uart.h
    ../lib/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_exti.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c
    ../lib/uip/: clock-arch.c clock-arch.h netdev.c netdev.h uip-conf.h
    ../lib/: stm32f2xx_hal_conf.h system_stm32f2xx.c
  group App
    ../: boot.c boot.h header.h led.c led.h main.c net.c net.h shared_params.c shared_params.h timer.c timer.h startup_stm32f207xx.s
  group uIP
    ../../../../Source/third_party/uip/apps/dhcpc/: dhcpc.c dhcpc.h
    ../../../../Source/third_party/uip/uip/: clock.h lc.h lc-addrlabels.h lc-switch.h pt.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uip_timer.c uip_timer.h uiplib.c uiplib.h uip-neighbor.h uipopt.h uip-split.h
software components: CMSIS:CORE 4.3.0
