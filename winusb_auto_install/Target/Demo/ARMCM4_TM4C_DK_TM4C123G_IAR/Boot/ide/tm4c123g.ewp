# IAR project tm4c123g.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PGE TexasInstruments TM4C123GH6PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TM4C123GH6PGE; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\third_party\fatfs\src; ..\..\..\..\Source\ARMCM4_TM4C; ..\..\..\..\Source\ARMCM4_TM4C\IAR; ..; ..\lib; ..\lib\inc; ..\lib\driverlib; ..\lib\fatfs; ..\lib\cmsis\Include; ..\lib\cmsis\Device\TI\TM4C123; ..\lib\tinyusb\cfg; ..\lib\tinyusb\port\mentor\musb; ..\lib\tinyusb\src; ..\lib\tinyusb\class\hid; ..\lib\tinyusb\class\vendor; ..\lib\tinyusb\src\common; ..\lib\tinyusb\src\device; ..\lib\tinyusb\src\osal
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: openblt_dk_tm4c123g.bin
  ILINK.IlinkOutputFile: openblt_dk_tm4c123g.out
  ILINK.IlinkIcfFile: ..\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h cstart.s hooks.c led.c led.h main.c vectors.c
  group Boot/lib/cmsis
    ../lib/cmsis/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h tz_context.h
    ../lib/cmsis/Device/TI/TM4C123/: system_TM4C123.h TM4C123.h TM4C123GH6PGE.h
  group Boot/lib/driverlib
    ../lib/driverlib/: adc.c adc.h can.c can.h comp.c comp.h cpulib.c cpulib.h debug.h eeprom.c eeprom.h flashlib.c flashlib.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timerlib.c timerlib.h uartlib.c uartlib.h udma.c udma.h usbdrv.c usbdrv.h watchdog.c watchdog.h
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/inc
    ../lib/inc/: asmdefs.h hw_adc.h hw_can.h hw_comp.h hw_eeprom.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lpc.h hw_memmap.h hw_nvic.h hw_peci.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pge.h
  group Boot/lib/tinyusb/cfg
    ../lib/tinyusb/cfg/: tusb_config.h usb_descriptors.c
  group Boot/lib/tinyusb/port
    ../lib/tinyusb/port/mentor/musb/: dcd_musb.c musb_tm4c.h musb_type.h
  group Boot/lib/tinyusb/src
    ../lib/tinyusb/src/: tusb.c tusb.h tusb_option.h
  group Boot/lib/tinyusb/src/class
    ../lib/tinyusb/src/class/hid/: hid.h hid_device.c hid_device.h hid_host.c hid_host.h
    ../lib/tinyusb/src/class/vendor/: vendor_device.c vendor_device.h vendor_host.c vendor_host.h
  group Boot/lib/tinyusb/src/common
    ../lib/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_timeout.h tusb_types.h tusb_verify.h
  group Boot/lib/tinyusb/src/device
    ../lib/tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
  group Boot/lib/tinyusb/src/osal
    ../lib/tinyusb/src/osal/: osal.h osal_none.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h com.c com.h cop.c cop.h cpu.h file.c file.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM4_TM4C
    ../../../../Source/ARMCM4_TM4C/: cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h usb.c
  group Source/ARMCM4_TM4C/IAR
    ../../../../Source/ARMCM4_TM4C/IAR/: cpu_comp.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/third_party/fatfs/src/option/: unicode.c
