# Keil uVision project stm32f103.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: openblt_olimex_stm32p103
  AfterMake: fromelf --m32 --output=..\bin\openblt_olimex_stm32p103.srec ..\bin\openblt_olimex_stm32p103.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB,reset_handler=Reset_Handler
  c misc: --diag_suppress=111 --diag_suppress=550
  c include: ..\lib;..\lib\fatfs;..\lib\CMSIS\Include;..\lib\CMSIS\Device\ST\STM32F1xx\Include;..\lib\STM32F1xx_HAL_Driver\Inc;..\lib\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\..\..\Source;..\..\..\..\Source\ARMCM3_STM32F1;..\..\..\..\Source\ARMCM3_STM32F1\Keil;..\..\..\..\Source\third_party\fatfs\src;..\..\Boot
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\memory.x
  group Lib
    ../lib/fatfs/: ffconf.h mmc.c
    ../lib/: stm32f1xx_hal_conf.h system_stm32f1xx.c
    ../lib/CMSIS/Device/ST/STM32F1xx/Include/: stm32f1xx.h stm32f103xb.h system_stm32f1xx.h
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../lib/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_rcc.c stm32f1xx_ll_spi.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c
    ../lib/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cortex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_dma.h stm32f1xx_ll_exti.h stm32f1xx_ll_gpio.h stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.h stm32f1xx_ll_spi.h stm32f1xx_ll_system.h stm32f1xx_ll_usart.h stm32f1xx_ll_utils.h
    ../lib/STM32F1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group App
    ../: blt_conf.h hooks.c main.c led.c led.h startup_stm32f103xb.s
  group Core
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h nvm.h plausibility.h timer.h xcp.c xcp.h rs232.h
    ../../../../Source/third_party/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/third_party/fatfs/src/option/: unicode.c
    ../../../../Source/ARMCM3_STM32F1/: can.c cpu.c flash.c flash.h nvm.c timer.c types.h usb.c rs232.c
    ../../../../Source/ARMCM3_STM32F1/Keil/: cpu_comp.c
