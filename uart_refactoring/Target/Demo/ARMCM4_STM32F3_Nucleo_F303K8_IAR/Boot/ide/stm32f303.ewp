# IAR project stm32f303.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303K8 ST STM32F303K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32F303x8
  ICCARM.CCIncludePath2: ..; ..\lib; ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32F3xx\Include; ..\lib\STM32F3xx_HAL_Driver\Inc; ..\lib\STM32F3xx_HAL_Driver\Inc\Legacy; ..\..\..\..\Source; ..\..\..\..\Source\ARMCM4_STM32F3; ..\..\..\..\Source\ARMCM4_STM32F3\IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: openblt_stm32f303.srec
  ILINK.IlinkOutputFile: openblt_stm32f303.out
  ILINK.IlinkIcfFile: ..\stm32f303k8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Boot
    ../: blt_conf.h hooks.c led.c led.h main.c startup_stm32f303.s
  group Boot/lib
    ../lib/: stm32f3xx_hal_conf.h system_stm32f3xx.c
  group Boot/lib/CMSIS
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
    ../lib/CMSIS/Device/ST/STM32F3xx/Include/: stm32f303x8.h stm32f3xx.h system_stm32f3xx.h
  group Boot/lib/HAL
    ../lib/STM32F3xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_can.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_rcc.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
    ../lib/STM32F3xx_HAL_Driver/Inc/: stm32f3xx_hal.h stm32f3xx_hal_can.h stm32f3xx_hal_cortex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h stm32f3xx_ll_bus.h stm32f3xx_ll_cortex.h stm32f3xx_ll_dma.h stm32f3xx_ll_exti.h stm32f3xx_ll_gpio.h stm32f3xx_ll_pwr.h stm32f3xx_ll_rcc.h stm32f3xx_ll_system.h stm32f3xx_ll_usart.h stm32f3xx_ll_utils.h
  group Source
    ../../../../Source/: assert.c assert.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM4_STM32F3
    ../../../../Source/ARMCM4_STM32F3/: can.c cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h
  group Source/ARMCM4_STM32F3/IAR
    ../../../../Source/ARMCM4_STM32F3/IAR/: cpu_comp.c
