# Keil uVision project stm32l552.uvprojx, settings and files
target Target (6160000::V6.16::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: openblt_stm32l552
  AfterMake: fromelf --m32 --output=..\bin\openblt_stm32l552.srec ..\bin\openblt_stm32l552.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L552xx
  c include: ..\..\Boot;..\lib;..\lib\CMSIS\Device\ST\STM32L5xx\Include;..\lib\CMSIS\Include;..\lib\STM32_USB_Device_Library\Core\Inc;..\lib\STM32L5xx_HAL_Driver\Inc;..\lib\STM32L5xx_HAL_Driver\Inc\Legacy;..\..\..\..\Source;..\..\..\..\Source\ARMCM33_STM32L5
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\stm32l552xe_flash.sct
  group Lib
    ../lib/CMSIS/Device/ST/STM32L5xx/Include/: stm32l5xx.h stm32l552xx.h system_stm32l5xx.h
    ../lib/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
    ../lib/STM32_USB_Device_Library/Core/Inc/: usbd_core.h usbd_ctlreq.h usbd_def.h usbd_ioreq.h
    ../lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../lib/STM32L5xx_HAL_Driver/Inc/: stm32l5xx_hal.h stm32l5xx_hal_cortex.h stm32l5xx_hal_def.h stm32l5xx_hal_dma.h stm32l5xx_hal_dma_ex.h stm32l5xx_hal_exti.h stm32l5xx_hal_fdcan.h stm32l5xx_hal_flash.h stm32l5xx_hal_flash_ex.h stm32l5xx_hal_flash_ramfunc.h stm32l5xx_hal_gpio.h stm32l5xx_hal_gpio_ex.h stm32l5xx_hal_i2c.h stm32l5xx_hal_i2c_ex.h stm32l5xx_hal_icache.h stm32l5xx_hal_pcd.h stm32l5xx_hal_pcd_ex.h stm32l5xx_hal_pwr.h stm32l5xx_hal_pwr_ex.h stm32l5xx_hal_rcc.h stm32l5xx_hal_rcc_ex.h stm32l5xx_hal_tim.h stm32l5xx_hal_tim_ex.h stm32l5xx_ll_bus.h stm32l5xx_ll_cortex.h stm32l5xx_ll_crs.h stm32l5xx_ll_dma.h stm32l5xx_ll_dmamux.h stm32l5xx_ll_exti.h stm32l5xx_ll_gpio.h stm32l5xx_ll_lpuart.h stm32l5xx_ll_pwr.h stm32l5xx_ll_rcc.h stm32l5xx_ll_system.h stm32l5xx_ll_usb.h stm32l5xx_ll_utils.h
    ../lib/STM32L5xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_fdcan.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_pcd.c stm32l5xx_hal_pcd_ex.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_ll_dma.c stm32l5xx_ll_exti.c stm32l5xx_ll_gpio.c stm32l5xx_ll_lpuart.c stm32l5xx_ll_pwr.c stm32l5xx_ll_rcc.c stm32l5xx_ll_usb.c stm32l5xx_ll_utils.c
    ../lib/: stm32l5xx_hal_conf.h system_stm32l5xx.c
  group App
    ../: blt_conf.h hooks.c led.c led.h main.c usbd_bulk.c usbd_bulk.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h startup_stm32l552xx.s
  group Core
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h can.h com.c com.h cop.c cop.h cpu.h file.c file.h net.c net.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
    ../../../../Source/ARMCM33_STM32L5/: can.c cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h usb.c
    ../../../../Source/ARMCM33_STM32L5/Keil/: cpu_comp.c
