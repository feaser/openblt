# IAR project tm4c123g.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PGE TexasInstruments TM4C123GH6PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Source; ..\..\..\..\Source\third_party\fatfs\src; ..\..\..\..\Source\ARMCM4_TM4C; ..\..\..\..\Source\ARMCM4_TM4C\IAR; ..; ..\lib; ..\lib\inc; ..\lib\driverlib; ..\lib\fatfs; ..\lib\usblib; ..\lib\usblib\config; ..\lib\usblib\device; ..\lib\usblib\host
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: openblt_dk_tm4c123g.bin
  ILINK.IlinkOutputFile: openblt_dk_tm4c123g.out
  ILINK.IlinkIcfFile: ..\memory.x
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot
    ../: blt_conf.h cstart.s hooks.c led.c led.h main.c vectors.c
  group Boot/lib/driverlib
    ../lib/driverlib/: adc.c adc.h can.c can.h comp.c comp.h cpulib.c cpulib.h debug.h eeprom.c eeprom.h flashlib.c flashlib.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timerlib.c timerlib.h uartlib.c uartlib.h udma.c udma.h usbdrv.c usbdrv.h watchdog.c watchdog.h
  group Boot/lib/fatfs
    ../lib/fatfs/: ffconf.h mmc.c
  group Boot/lib/inc
    ../lib/inc/: asmdefs.h hw_adc.h hw_can.h hw_comp.h hw_eeprom.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lpc.h hw_memmap.h hw_nvic.h hw_peci.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pge.h
  group Boot/lib/usblib
    ../lib/usblib/: usb-ids.h usbaudio.h usbbuffer.c usbcdc.h usbdesc.c usbdfu.h usbdma.c usbhid.h usbkeyboardmap.c usblib.h usblibpriv.h usbmode.c usbmsc.h usbringbuf.c usbtick.c
  group Boot/lib/usblib/config
    ../lib/usblib/config/: usb_bulk_structs.c usb_bulk_structs.h
  group Boot/lib/usblib/device
    ../lib/usblib/device/: usbdaudio.c usbdaudio.h usbdbulk.c usbdbulk.h usbdcdc.c usbdcdc.h usbdcdesc.c usbdcomp.c usbdcomp.h usbdconfig.c usbddfu-rt.c usbddfu-rt.h usbdenum.c usbdevice.h usbdevicepriv.h usbdhandler.c usbdhid.c usbdhid.h usbdhidkeyb.c usbdhidkeyb.h usbdhidmouse.c usbdhidmouse.h usbdmsc.c usbdmsc.h
  group Boot/lib/usblib/host
    ../lib/usblib/host/: usbhaudio.c usbhaudio.h usbhhid.c usbhhid.h usbhhidkeyboard.c usbhhidkeyboard.h usbhhidmouse.c usbhhidmouse.h usbhhub.c usbhhub.h usbhmsc.c usbhmsc.h usbhost.h usbhostenum.c usbhostpriv.h usbhscsi.c usbhscsi.h
  group Source
    ../../../../Source/: asserts.c asserts.h backdoor.c backdoor.h boot.c boot.h com.c com.h cop.c cop.h cpu.h file.c file.h nvm.h plausibility.h rs232.h timer.h usb.h xcp.c xcp.h
  group Source/ARMCM4_TM4C
    ../../../../Source/ARMCM4_TM4C/: cpu.c flash.c flash.h nvm.c rs232.c timer.c types.h usb.c
  group Source/ARMCM4_TM4C/IAR
    ../../../../Source/ARMCM4_TM4C/IAR/: cpu_comp.c
  group Source/third_party/fatfs
    ../../../../Source/third_party/fatfs/src/: diskio.h ff.c ff.h integer.h
    ../../../../Source/third_party/fatfs/src/option/: unicode.c
