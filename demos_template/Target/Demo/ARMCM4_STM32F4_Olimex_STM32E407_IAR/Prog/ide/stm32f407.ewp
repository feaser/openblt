# IAR project stm32f407.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..; ..\lib\; ..\lib\CMSIS\Device\ST\STM32F4xx\Include; ..\lib\CMSIS\Include; ..\lib\STM32F4xx_HAL_Driver\Inc; ..\lib\STM32F4xx_HAL_Driver\Inc\Legacy
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demoprog_olimex_stm32e407.srec
  ILINK.IlinkOutputFile: demoprog_olimex_stm32e407.out
  ILINK.IlinkIcfFile: ..\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Prog
    ../: boot.c boot.h header.h led.c led.h main.c startup_stm32f407xx.s timer.c timer.h
  group Prog/lib
    ../lib/: stm32f4xx_hal_conf.h system_stm32f4xx.c
  group Prog/lib/CMSIS
    ../lib/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../lib/CMSIS/Device/ST/STM32F4xx/Include/: stm32f407xx.h stm32f4xx.h system_stm32f4xx.h
  group Prog/lib/HAL
    ../lib/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
    ../lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ../lib/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_can.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h
